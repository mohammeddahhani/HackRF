<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>C:\Users\SDR ACT Project\Desktop\MohammedDAHHANI\static_video_tx_rx\IN.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>1.2e9</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
